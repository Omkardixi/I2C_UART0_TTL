# Keil uVision project I2C_UART0_TTL.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: I2C_UART0_TTL +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\driverlib;.\FreeRTOS;.\utils;.\inc;..\I2C_FreeRTOS
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: main.c
    ./utils/: uartstdio.c
    ./driverlib/: gpio.c cpu.c i2c.c interrupt.c sysctl.c uart.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
